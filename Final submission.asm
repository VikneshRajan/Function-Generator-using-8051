ORG 0000h
	MOV P1,#0Fh
	MOV P0,#00h
LO:	MOV R4,#0Ah
	JNB P1.0,LOOPP
	JNB P1.1,SINEWAVE
	JNB P1.2,tri
	JNB P1.3,SAWTOOTH
	SJMP LO
LOOPP:MOV R0,#0FFh
	  MOV R1,#10h
	  SJMP loop
LOOP2:SJMP tri
loop: 
			MOV P0,#0FFh      
			 ACALL DELAY
			 MOV P0,#00h
			 ACALL DELAY
			 SJMP loop
		DELAY:MOV R2,#0EEh
		loop3:
		loopp1: DJNZ R0,loopp1
		loopp2: DJNZ R1,loopp2
		DJNZ R2,loop3
		RET
SINEWAVE: MOV P0,#00h
SINEWAVE1:		MOV DPTR, #SINE
		MOV R2,#13
NEXT: CLR A
MOVC A, @A+DPTR
JZ SINEWAVE
MOV P0,A
INC DPTR
DJNZ R2, NEXT
SJMP SINEWAVE
RET
ORG 050H
SINE : DB 27, 160, 191, 217, 237, 250, 255, 250, 237, 217, 191, 160, 127, 94, 63, 37, 17, 4, 1, 4, 17, 37, 63, 94, 127
	
SAWTOOTH: MOV A, #00H
BACK: MOV P0,A
INC A
CJNE A,#255, BACK
MOV A,#00
SJMP SAWTOOTH
RET

tri:		MOV P0,#00h
	MOV A,P0
	main: MOV A,#00h
	up: MOV P0,A
		INC A
		CJNE A,#0FFh,up
	dn: MOV P0,A
		DEC A
		CJNE A,#00h,dn
		JMP main
END